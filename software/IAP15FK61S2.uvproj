# Keil uVision project IAP15FK61S2.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: IAP15FK61S2 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\libraries\sushizhou_common;.\libraries\sushizhou_device;.\libraries\sushizhou_drive;.\user
  group user
    ./user/: main.c su_S12.c
    ./: STARTUP.A51
  group common
    ./libraries/sushizhou_common/: delay.c
  group drive
    ./libraries/sushizhou_drive/: timer.c iic.c su_usart.c su_exit.c
  group device
    ./libraries/sushizhou_device/: su_key.c su_digital_tube.c su_ds1302.c su_ds18b20.c su_pcf8591.c su_eeprom .c
