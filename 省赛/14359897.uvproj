# Keil uVision project 14359897.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 14359897 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\library\common;.\library\device;.\library\drive;.\usr
  group usr
    ./: STARTUP.A51
    ./usr/: main.c
  group drive
    ./library/drive/: iic.c onewire.c su_usart.c timer.c
  group device
    ./library/device/: su_digital_tube.c su_latch.c su_ne555.c su_ds1302.c su_key.c su_ds18b20.c su_pcf8591.c
