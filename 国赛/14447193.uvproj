# Keil uVision project 14447193.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 14447193 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\user;.\libraries\sushizhou_common;.\libraries\sushizhou_device;.\libraries\sushizhou_drive
  group user
    ./: STARTUP.A51
    ./user/: main.c
  group sushizhou_common
    ./libraries/sushizhou_common/: delay.c
  group sushizhou_drive
    ./libraries/sushizhou_drive/: iic.c onewire.c su_usart.c timer.c
  group sushizhou_device
    ./libraries/sushizhou_device/: su_digital_tube.c su_led.c su_latch.c su_key.c su_ds18b20.c su_ultrasonic.c su_pcf8591.c
